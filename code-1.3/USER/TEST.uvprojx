# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TEST +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\OBJ\TEST.bin ..\OBJ\TEST.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F767xx
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\UCOSII\uC-LIB;..\UCOSII\uC-CPU;..\UCOSII\UCOS_BSP;..\UCOSII\uCOS-CONFIG;..\UCOSII\uCOS-II\Source;..\UCOSII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSII\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE\24CXX;..\HARDWARE\WKUP;..\HARDWARE\RTC;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\SC50;..\HARDWARE\TRANSFER;..\FATFS\src;..\FATFS\exfuns;..\HARDWARE\SDMMC;..\MALLOC;..\HARDWARE\W25QXX;..\HARDWARE\NAND;..\HARDWARE\QSPI;..\USMART;..\HARDWARE\WDG;..\HARDWARE\CRC16;..\HARDWARE\KEY
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: startup_stm32f767xx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMA/: DMA.c
    ../HARDWARE/SC50/: SC50.c
    ../HARDWARE/TRANSFER/: TRANSFER.c
    ../HARDWARE/SDMMC/: sdmmc_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/NAND/: nand.c ftl.c nandtester.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/CRC16/: CRC16.c
    ../HARDWARE/KEY/: key.c
  group UCOSII_BSP
    ../UCOSII/UCOS_BSP/: bsp.c cpu_bsp.c
  group UCOSII_CPU
    ../UCOSII/uC-CPU/: cpu_core.c
    ../UCOSII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSII_LIB
    ../UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSII_CORE
    ../UCOSII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII_CONFIG
    ../UCOSII/uCOS-CONFIG/: app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group README
    ../: readme.txt
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
